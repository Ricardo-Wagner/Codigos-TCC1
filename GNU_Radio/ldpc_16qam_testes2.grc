options:
  parameters:
    generate_options: qt_gui
    id: ldpc_16qam_testes2
    output_language: python
    title: ldpc_16qam_testes2
  states: {}

blocks:
- name: K
  id: variable
  parameters:
    value: 22*z
  states: {}
- name: N_total
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: bit_rate/bits_per_symbol
  states: {}
- name: bg
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: 800e3
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: '4'
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    start: '0.99'
    step: '0.0001'
    stop: '1.01'
    value: '1.0'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    start: '-0.002'
    step: '0.00001'
    stop: '0.002'
    value: '0.0'
  states: {}
- name: gap
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ils
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ldpc_H_matrix
  id: variable_ldpc_H_matrix_def
  parameters:
    filename: path_alist
    gap: gap
  states: {}
- name: ldpc_decoder
  id: variable_ldpc_decoder_def
  parameters:
    file: path_alist
    max_iter: '1'
    ndim: '0'
  states: {state: disabled}
- name: ldpc_decoder
  id: variable_ldpc_decoder_def
  parameters:
    file: path_alist
    max_iter: '50'
    ndim: '0'
  states: {}
- name: ldpc_encoder
  id: variable_ldpc_encoder_H_def
  parameters:
    H: ldpc_H_matrix
    ndim: '0'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '8'
    value: '0.8'
  states: {}
- name: path_alist
  id: variable
  parameters:
    value: '"../alists/NR_{}_{}_{}_{}.alist".format(bg, ils, z, gap)'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: 68*z
  states: {}
- name: payload_len_bytes
  id: variable
  parameters:
    value: payload_len/8
  states: {}
- name: preambulo
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_filter_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.25'
    gain: sps
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: baud_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: stats
  id: variable
  parameters:
    value: '{''det'': 0, ''ok'': 0, ''n_total'': N_total}'
  states: {}
- name: taps
  id: variable
  parameters:
    value: np.array(rrc_filter_taps)
  states: {}
- name: z
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: alice.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: N_total*(preambulo+payload_len)
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: bits_per_symbol
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (preambulo,payload_len)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: K-32
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: K
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: bit_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0xE1, 0x5A, 0xE8, 0x93)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: epsilon
    freq_offset: freq_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: const
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: const
    fmax: '0.05'
    fmin: '-0.05'
    loop_bw: 2*np.pi/100
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'False'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'False'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.basic_block):
          def __init__(self, constellation=None, access_code="10101010", payload_len_in_bits=272, threshold=5.0):
              gr.basic_block.__init__(
                  self,
                  name='Find access code + soft decode (symbol domain)',
                  in_sig=[np.complex64],
                  out_sig=[np.float32]
              )
              self.access_code = access_code
              self.payload_len_in_bits = payload_len_in_bits
              self.threshold = threshold

              self.constellation = None
              self.rotations = []
              self.payload_len_in_symbols = 0
              self.bits_per_symbol = 0

              self._min_dist = [float('inf')] * 4
              self._call_count = 0
              self._last_npwr = None

              if constellation is not None:
                  self._setup(constellation)

          def _setup(self, constellation):
              self.constellation = constellation
              bps = constellation.bits_per_symbol()
              self.bits_per_symbol = bps

              bits = [int(b) for b in self.access_code]
              assert len(bits) % bps == 0, "access_code precisa ser múltiplo de bits_per_symbol"

              ref = []
              for i in range(0, len(bits), bps):
                  idx = 0
                  for b in bits[i:i + bps]:
                      idx = (idx << 1) | b
                  ref.append(constellation.map_to_points_v(idx)[0])
              base = np.array(ref, dtype=np.complex64)

              # as 4 rotações possíveis da referência (simetria de ordem 4 do 16QAM)
              self.rotations = [base * (1j ** k) for k in range(4)]

              assert self.payload_len_in_bits % bps == 0
              self.payload_len_in_symbols = self.payload_len_in_bits // bps

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              out0 = output_items[0]

              if not self.rotations:
                  # ainda não inicializado de verdade (ex.: passada de descoberta do GRC)
                  return 0

              ac_len = self.rotations[0].size
              pl_len = self.payload_len_in_symbols
              out_len_needed = pl_len * self.bits_per_symbol

              if len(in0) < ac_len + pl_len:
                  return 0
              if len(out0) < out_len_needed:
                  return 0

              window = in0[:ac_len]
              dists = [np.sum(np.abs(window - ref) ** 2) for ref in self.rotations]
              best_k = int(np.argmin(dists))
              best_dist = dists[best_k]

              # --- diagnóstico opcional (pode remover depois de validar) ---
              #for k in range(4):
              #    self._min_dist[k] = min(self._min_dist[k], dists[k])
              #self._call_count += 1
              #if self._call_count % 2000 == 0:
              #    print(f"menor dist_sq por rotação (0,90,180,270): {self._min_dist}  "
              #          f"| último npwr medido: {self._last_npwr}")
              #    self._min_dist = [float('inf')] * 4
              # ---------------------------------------------------------------

              if best_dist > self.threshold:
                  self.consume(0, 1)
                  return 0

              # ruído medido na própria janela do access code que acabou de bater
              measured_npwr = max(best_dist / ac_len, 1e-6)
              self._last_npwr = measured_npwr

              # corrige a rotação nos símbolos do payload
              payload_symbols = in0[ac_len: ac_len + pl_len] * (1j ** (-best_k))

              # decisão soft símbolo a símbolo, usando o ruído medido agora
              soft_bits = np.concatenate([
                  self.constellation.calc_soft_dec(sym, measured_npwr)
                  for sym in payload_symbols
              ]).astype(np.float32)

              out0[:out_len_needed] = soft_bits
              self.consume(0, ac_len + pl_len)
              return out_len_needed
    access_code: access_code
    constellation: const
    payload_len_in_bits: payload_len
    threshold: '2'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import threading, time
      import numpy as np
      import pmt
      from gnuradio import gr

      class blk(gr.sync_block):
          """Repassa o fluxo e conta tags 'packet_len' em stats[name]."""
          def __init__(self, stats=None, name='ok', key='packet_len',
                       report=False):
              gr.sync_block.__init__(self, name='Tag counter',
                                     in_sig=[np.uint8], out_sig=[np.uint8])
              self.stats = stats if stats is not None else {'det': 0, 'ok': 0}
              self.cname = name
              self.key = pmt.intern(key)
              self.report = report
              self._run = False
              self.stats.setdefault(name, 0)

          def work(self, input_items, output_items):
              n = len(input_items[0])
              output_items[0][:n] = input_items[0]
              tags = self.get_tags_in_window(0, 0, n, self.key)
              self.stats[self.cname] += len(tags)
              return n

          def _print(self, tag):
              det = self.stats.get('det', 0)
              ok = self.stats.get('ok', 0)
              N = self.stats.get('n_total', 0)
              if N:
                  print(f"[{tag}] N={N} | det={det} ({det/N:.4f}) | "
                        f"ok={ok} ({ok/N:.4f}) | "
                        f"BLER|det={(det-ok)/max(det,1):.3e} | "
                        f"BLER total={(N-ok)/N:.3e}")

          def _loop(self):
              prev, calmo = None, 0
              while self._run:
                  time.sleep(1.0)
                  self._print('parcial')
                  cur = (self.stats.get('det', 0), self.stats.get('ok', 0))
                  calmo = calmo + 1 if (cur == prev and cur[0] > 0) else 0
                  prev = cur
                  if calmo >= 3:
                      self._print('FINAL')
                      break

          def start(self):
              if self.report:
                  self._run = True
                  threading.Thread(target=self._loop, daemon=True).start()
              return True

          def stop(self):
              self._run = False
              return True
    key: '''packet_len'''
    name: '''det'''
    report: 'False'
    stats: stats
  states: {}
- name: epy_block_1_0_0
  id: epy_block
  parameters:
    _source_code: |
      import threading, time
      import numpy as np
      import pmt
      from gnuradio import gr

      class blk(gr.sync_block):
          """Repassa o fluxo e conta tags 'packet_len' em stats[name]."""
          def __init__(self, stats=None, name='ok', key='packet_len',
                       report=False):
              gr.sync_block.__init__(self, name='Tag counter',
                                     in_sig=[np.uint8], out_sig=[np.uint8])
              self.stats = stats if stats is not None else {'det': 0, 'ok': 0}
              self.cname = name
              self.key = pmt.intern(key)
              self.report = report
              self._run = False
              self.stats.setdefault(name, 0)

          def work(self, input_items, output_items):
              n = len(input_items[0])
              output_items[0][:n] = input_items[0]
              tags = self.get_tags_in_window(0, 0, n, self.key)
              self.stats[self.cname] += len(tags)
              return n

          def _print(self, tag):
              det = self.stats.get('det', 0)
              ok = self.stats.get('ok', 0)
              N = self.stats.get('n_total', 0)
              if N:
                  print(f"[{tag}] N={N} | det={det} ({det/N:.4f}) | "
                        f"ok={ok} ({ok/N:.4f}) | "
                        f"BLER|det={(det-ok)/max(det,1):.3e} | "
                        f"BLER total={(N-ok)/N:.3e}")

          def _loop(self):
              prev, calmo = None, 0
              while self._run:
                  time.sleep(1.0)
                  self._print('parcial')
                  cur = (self.stats.get('det', 0), self.stats.get('ok', 0))
                  calmo = calmo + 1 if (cur == prev and cur[0] > 0) else 0
                  prev = cur
                  if calmo >= 3:
                      self._print('FINAL')
                      break

          def start(self):
              if self.report:
                  self._run = True
                  threading.Thread(target=self._loop, daemon=True).start()
              return True

          def stop(self):
              self._run = False
              return True
    key: '''packet_len'''
    name: '''ok'''
    report: 'True'
    stats: stats
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_decoder
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_encoder
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: taps
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: taps/sps
    type: ccc
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2000'
    type: byte
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1:3,0,1,1
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1:2,0,1,1
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:1,0,1,1
    type: complex
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:0,0,1,1
    type: float
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Transmissor
    label1: Receptor
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_sink
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx_sink
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_sink_x_1_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_head_0, '0', blocks_throttle2_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', network_tcp_sink_0_0, '0']
- [blocks_pack_k_bits_bb_1, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_stream_mux_0, '0', blocks_head_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', epy_block_1_0, '0']
- [blocks_throttle2_0_0, '0', blocks_char_to_float_0, '0']
- [blocks_throttle2_0_0, '0', blocks_pack_k_bits_bb_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [channels_channel_model_0, '0', virtual_sink_1, '0']
- [digital_constellation_encoder_bc_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_sink_x_1, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_null_sink_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_1, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0_2, '0']
- [digital_constellation_receiver_cb_0, '4', epy_block_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_sink_x_0_0, '0']
- [digital_crc32_bb_0, '0', fec_extended_encoder_0, '0']
- [digital_crc32_bb_0_0, '0', epy_block_1_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [epy_block_0, '0', fec_extended_decoder_0_0, '0']
- [epy_block_1_0, '0', digital_crc32_bb_0_0, '0']
- [epy_block_1_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [fec_extended_decoder_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [fec_extended_encoder_0, '0', blocks_stream_mux_0, '1']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [interp_fir_filter_xxx_1, '0', digital_symbol_sync_xx_0, '0']
- [interp_fir_filter_xxx_1, '0', qtgui_sink_x_0_0_0, '0']
- [virtual_source_0, '0', channels_channel_model_0, '0']
- [virtual_source_1, '0', interp_fir_filter_xxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
