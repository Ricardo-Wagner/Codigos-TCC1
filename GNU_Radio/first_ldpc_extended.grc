options:
  parameters:
    generate_options: qt_gui
    id: first_ldpc
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: ldpc_H_matrix
  id: variable_ldpc_H_matrix_def
  parameters:
    filename: /home/ricardowagner/NextCloud2/Drive/Faculdade/TCC1/Codigos/alists/bg2_ils0_zc2_gap1.alist
    gap: '1'
  states: {}
- name: ldpc_decoder
  id: variable_ldpc_decoder_def
  parameters:
    file: /home/ricardowagner/NextCloud2/Drive/Faculdade/TCC1/Codigos/alists/bg2_ils0_zc2_gap1.alist
    max_iter: '50'
    ndim: '0'
  states: {}
- name: ldpc_encoder
  id: variable_ldpc_encoder_H_def
  parameters:
    H: ldpc_H_matrix
    ndim: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_decoder
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_encoder
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    rate: samp_rate
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_char_to_float_0, '0', qtgui_sink_x_0, '0']
- [blocks_char_to_float_1, '0', fec_extended_decoder_0, '0']
- [blocks_throttle2_0, '0', fec_extended_encoder_0, '0']
- [fec_extended_decoder_0, '0', blocks_char_to_float_0, '0']
- [fec_extended_encoder_0, '0', blocks_char_to_float_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
