options:
  parameters:
    generate_options: qt_gui
    id: test_ldpc_16qam_soft
    output_language: python
    title: test_ldpc_16qam_soft
  states: {}

blocks:
- name: K
  id: variable
  parameters:
    value: 22*z
  states: {}
- name: access_code
  id: variable
  parameters:
    value: '"11100001010110101110100010010011"'
  states: {}
- name: baud_rate
  id: variable
  parameters:
    value: bit_rate/bits_per_symbol
  states: {}
- name: bg
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: 800e3
  states: {}
- name: bits_per_symbol
  id: variable
  parameters:
    value: '4'
  states: {}
- name: const
  id: variable_constellation
  parameters:
    precision: '8'
    type: 16qam
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    start: '0.99'
    step: '0.0001'
    stop: '1.01'
    value: '1.0'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    start: '-0.002'
    step: '0.00001'
    stop: '0.002'
    value: '0.0'
  states: {}
- name: gap
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ils
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ldpc_H_matrix
  id: variable_ldpc_H_matrix_def
  parameters:
    filename: path_alist
    gap: gap
  states: {}
- name: ldpc_decoder
  id: variable_ldpc_decoder_def
  parameters:
    file: path_alist
    max_iter: '1'
    ndim: '0'
  states: {state: disabled}
- name: ldpc_decoder
  id: variable_ldpc_decoder_def
  parameters:
    file: path_alist
    max_iter: '10'
    ndim: '0'
  states: {}
- name: ldpc_encoder
  id: variable_ldpc_encoder_H_def
  parameters:
    H: ldpc_H_matrix
    ndim: '0'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '8'
    value: '0'
  states: {}
- name: path_alist
  id: variable
  parameters:
    value: '"../alists/NR_{}_{}_{}_{}.alist".format(bg, ils, z, gap)'
  states: {}
- name: payload_len
  id: variable
  parameters:
    value: 68*z
  states: {}
- name: payload_len_bytes
  id: variable
  parameters:
    value: payload_len/8
  states: {}
- name: preambulo
  id: variable
  parameters:
    value: '64'
  states: {}
- name: rrc_filter_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: '0.25'
    gain: sps
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: baud_rate
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud_rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '10'
  states: {}
- name: taps
  id: variable
  parameters:
    value: np.array(rrc_filter_taps)
  states: {}
- name: z
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: alice.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: bits_per_symbol
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (preambulo,payload_len)
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"quadro"'
    packet_len: preambulo + payload_len
    type: byte
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: bit_rate
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0xE1, 0x5A, 0xE8, 0x93, 0x00, 0x22, 0x00, 0x22)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: epsilon
    freq_offset: freq_offset
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: const
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: const
    fmax: '0.05'
    fmin: '-0.05'
    loop_bw: 2*np.pi/100
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: const
    npwr: max(noise_voltage**2, 0.01)
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_code
    threshold: '2'
    type: float
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_decoder
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_encoder
    puncpat: '''11'''
    threadtype: capillary
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: taps
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_1
  id: interp_fir_filter_xxx
  parameters:
    interp: '1'
    taps: taps/sps
    type: ccc
  states: {}
- name: network_tcp_sink_0_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '2000'
    type: byte
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1:3,0,1,1
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@1:2,0,1,1
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:1,0,1,1
    type: complex
  states: {}
- name: qtgui_sink_x_1_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tabs@0:0,0,1,1
    type: float
  states: {}
- name: tabs
  id: qtgui_tab_widget
  parameters:
    label0: Transmissor
    label1: Receptor
    num_tabs: '2'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_sink
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx_sink
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_sink_x_1_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', network_tcp_sink_0_0, '0']
- [blocks_pack_k_bits_bb_1, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_stream_mux_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_throttle2_0_0, '0']
- [blocks_throttle2_0_0, '0', blocks_char_to_float_0, '0']
- [blocks_throttle2_0_0, '0', blocks_pack_k_bits_bb_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_extended_encoder_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [channels_channel_model_0, '0', virtual_sink_1, '0']
- [digital_constellation_encoder_bc_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_sink_x_1, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_null_sink_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_1, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0_2, '0']
- [digital_constellation_receiver_cb_0, '4', digital_constellation_soft_decoder_cf_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_sink_x_0_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', fec_extended_decoder_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [fec_extended_decoder_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [fec_extended_encoder_0, '0', blocks_stream_mux_0, '1']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [interp_fir_filter_xxx_1, '0', digital_symbol_sync_xx_0, '0']
- [interp_fir_filter_xxx_1, '0', qtgui_sink_x_0_0_0, '0']
- [virtual_source_0, '0', channels_channel_model_0, '0']
- [virtual_source_1, '0', interp_fir_filter_xxx_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
